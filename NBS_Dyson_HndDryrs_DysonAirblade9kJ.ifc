Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-01-16T12:33:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Jan 16 12:33:49 2020* Host: NCL-PI07* Database: C:\Users\WhittakL\AppData\Local\Temp\{A87DED7B-990E-4AF6-8741-B44FBD449F84}\ifc* Database version: 5507* Database creation date: Thu Jan 16 12:33:49 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Jan 16 12:33:49 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Jan 16 12:33:49 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowTerminal: Dyson Airblade 9kJ, NBS_Dyson_HndDryrs_DysonAirblade9kJ:Dyson Airblade 9kJ:311732
In: Level 0
Type - PredefinedType: HANDDRYER; Classification: Pr_40_70_62_37 (Uniclass2015); Material: NBS_Dyson_Grey
Type - BOS_General - Author: NBS; BIMObjectName: NBS_Dyson_HandDryers_DysonAirblade9kJ; ManufacturerName: Dyson; ManufacturerURL: http://www.dyson.co.uk/forbusiness; NBSCertification: www.nationalbimlibrary.com/cert/pzrjewfe; NBSDescription: Hand dryers; NBSReference: 45-35-72/334; ProductInformation: https://www.dyson.co.uk/commercial/hand-dryers/airblade-9kj.html; Revision: n/a; Uniclass2015Title: Hand dryers; Uniclass2015Code: Pr_40_70_62_37; Uniclass2015Version: Products v1.16; Version: 1
Type - NBS_Data - Standards: NSF approved, Quiet Mark, Carbon Trust certified; Form: High velocity air through HEPA filter; Operation: Touch free time of flight sensor activation; TimerModes: 10 seconds (MAX) mode , 12 seconds (ECO); ElectricalSupplyRatedOperationalVoltageUe: 160-253 V; ElectricalSupplyFrequency: 50-60 Hz; BodyMaterial: Stainless Steel; SurfaceFinish: Satin Finish; BodyColour: Stainless Steel; BodyIngressProtectionMinimum: IP24; Dimensions: 500 x 450 x 100 mm; NoiseLevelAtOneMetreMaximum: n/a; Weight: 4.5 kg; MotorType: Dyson digital brushless motor; MotorPower: 600-950 W; OperatingTemperature: 0-40°C; Filter: HEPA filter (Glass fibre and fleece prelayer), Captures 99.95% of particles, including bacteria and viruses; QuietMark: https://www.quietmark.com/products/search/dyson-airblade-9kj; AirSpeed: 388 mph; Applications: Workplace, Hospitality, High Footfall, Education; Approval: Carbon Trust, Quiet Mark, NSF
Type - Pset_ElectricalDeviceCommon - ConductorFunction: n/a; HasProtectiveEarth: no; IK_Code: n/a; InsulationStandardClass: n/a; IP_Code: IP24; NominalFrequencyRange: 50-60 Hz; NumberOfPoles: 0; PowerFactor: 0; RatedCurrent: n/a; RatedVoltage: 220-240 V
Type - IFC - IfcExportAs: IfcElectricApplianceType; IfcExportType: HANDDRYER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_62_37:Hand dryers; CodePerformance: BREEAM, LEED, WELL; Color: Brushed Stainless Steel; Constituents: n/a; Description: The Dyson Airblade 9kJ hand dryer is the fastest most energy efficient HEPA-filtered hand dryer.; DurationUnit: 5 year; ExpectedLife: n/a; Features: Energy efficient, hygienic, quick drying, quiet.; Finish: Brushed Stainless Steel; Grade: 304L; Manufacturer: specification@dyson.com; Material: Stainless Steel; ModelNumber: HU03; ModelReference: Dyson Airblade 9kJ; Name: HandDryers_DysonAirblade9kJ_Dyson; NominalHeight: 500 mm; NominalLength: 450 mm; NominalWidth: 100 mm; ReplacementCost: n/a; Shape: n/a; Size: 500 x 450 x 100 mm; SustainabilityPerformance: n/a; WarrantyDescription: 5 years; WarrantyDurationLabor: 5 years; WarrantyDurationParts: 5 years; WarrantyDurationUnit: 5 years; WarrantyGuarantorLabor: 5 years; WarrantyGuarantorParts: askdyson@dyson.com
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
